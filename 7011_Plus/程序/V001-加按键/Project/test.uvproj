# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8F2K64S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User\AppCode\AppLayer;..\User\AppCode\DriverLayer;..\User\AppCode\ManageLayer;..\User\AppCode\WIFILayer;..\User\SysCode\Core
  group User_AppCode_AppLayer
    ../User/AppCode/AppLayer/: Main.c
  group User_AppCode_ManageLayer
    ../User/AppCode/ManageLayer/: TaskProc.c StateProc.c KeyProc.c LedProc.c ParaProc.c SysDataDef.c WifiProc.c
  group User_AppCode_WIFILayer
    ../User/AppCode/WIFILayer/: mcu_api.c protocol.c system.c wifi.h
  group User_AppCode_DriverLayer
    ../User/AppCode/DriverLayer/: Timer.c Gpio.c Rcc.c Interrupt.c Usart.c
